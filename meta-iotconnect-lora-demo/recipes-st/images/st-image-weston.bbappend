# Copyright (C) 2019, STMicroelectronics - All Rights Reserved

SUMMARY = "Recipe to add iotconnect"

CORE_IMAGE_EXTRA_INSTALL += " \
    lora \
    "